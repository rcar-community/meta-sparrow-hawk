require core-image-minimal.inc

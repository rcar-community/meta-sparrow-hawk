DUMMYPROVIDES:append:sparrow-hawk = " /bin/sed"


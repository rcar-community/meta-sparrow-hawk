PACKAGECONFIG:append:pn-gnutls-native = " p11-kit"

core-image-weston.bbappend
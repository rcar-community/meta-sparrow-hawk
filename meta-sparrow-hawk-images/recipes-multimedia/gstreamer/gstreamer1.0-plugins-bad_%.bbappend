PACKAGECONFIG:append:sparrow-hawk = " kms"


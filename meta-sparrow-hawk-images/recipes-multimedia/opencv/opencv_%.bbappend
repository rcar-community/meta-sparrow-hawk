PACKAGECONFIG:append:sparrow-hawk = " gtk opencl dnn"

DUMMYPROVIDES:append:rcar-gen4 = " /bin/sed"


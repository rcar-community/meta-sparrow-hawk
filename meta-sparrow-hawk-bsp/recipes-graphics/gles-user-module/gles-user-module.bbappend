PROVIDES += "virtual/libgles1 virtual/libgles3"

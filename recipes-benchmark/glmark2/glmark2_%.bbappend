# Fix include path issue
CFLAGS += "-I${STAGING_INCDIR}/gbm"
CXXFLAGS += "-I${STAGING_INCDIR}/gbm"
